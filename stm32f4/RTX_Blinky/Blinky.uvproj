# Keil uVision project Blinky.uvproj, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: NDEBUG
  c misc: --forceinline
  c include: ..\RTX_Blinky;.\STM32F4xx_StdPeriph_Driver\inc;.\zzbar;.\zzbar\decoder;.\zzbar\qrcode;.\STM32_EVAL\STM3240_41_G_EVAL;.\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x64000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group StartUp
    ./: startup_stm32f4xx.s system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h
  group Source Files
    ./: main.c console_usart.c console_usart.h camera.c camera.h i2c.c i2c.h ring_buffer.h sd.c sd.h wifi.c wifi.h mp3.c mp3.h timer.c timer.h
  group Documentation
    ./: Abstract.txt
  group zzbar
    ./zzbar/: config.c decoder.c error.c image.c refcnt.c scanner.c svg.c symbol.c img_scanner.c
    ./zzbar/qrcode/: bch15_5.c binarize.c isaac.c qrdec.c qrdectxt.c rs.c util.c
    ./zzbar/decoder/: code39.c code128.c ean.c i25.c qr_finder.c
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
